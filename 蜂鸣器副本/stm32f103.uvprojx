# Keil uVision project stm32f103.uvprojx, settings and files
target STM32F103 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32f103 +hex
  c flags: Optim=1 wLevel=2
  c define: STM32F10X_MD, USE_STDPERIPH_DRIVER
  c include: .\core;.\fwlib\inc;.\hardware\inc;.\user;.\NET\onenet\inc;.\NET\MQTT;.\NET\device\inc;.\hardware\DHT11;.\hardware\OLED;.\hardware\SHT30;.\hardware\LED;.\hardware\BUZZER;.\hardware\Lock;.\hardware\RGBLight;.\hardware\Sensor;.\hardware\BUZZER
  group core
    ./core/: core_cm3.c stm32f10x_it.c system_stm32f10x.c
    ./core/startup/arm/: startup_stm32f10x_hd.s
  group fwlib
    ./fwlib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_tim.c
  group hardware
    ./hardware/src/: delay.c usart.c sys.c
    ./hardware/OLED/: oled.c
    ./hardware/LED/: led.c
    ./hardware/Sensor/: Sensor.c
    ./hardware/BUZZER/: buzzer.c
    ./fwlib/src/: stm32f10x_adc.c
  group user
    ./user/: main.c
  group OneNET
    ./NET/onenet/src/: onenet.c hmac_sha1.c base64.c
  group net_protocol
    ./NET/MQTT/: MqttKit.c
  group net_device
    ./NET/device/src/: esp8266.c
software components: CMSIS:CORE 5.5.0
